* source NET_DFF_TG
M_M38         N47473 CLK N48007 N48601 MbreakP
+ L=.18u
+ W=.72u
V_V19         N47383 0 1.8Vdc
M_M27         N47627 N47473 N47631 N47631 MbreakP
+ L=.18u
+ W=1.8u
M_M35         OUTQBAR OUTQ N48241 N48241 MbreakP
+ L=.18u
+ W=1.8u
V_V27         N47875 0 1.8Vdc
M_M25         N47473 N47351 N47477 N47477 MbreakP
+ L=.18u
+ W=1.8u
V_V24         N48087 0 1.8Vdc
M_M28         N47627 N47473 0 0 MbreakN
+ L=.18u
+ W=.72u
M_M37         N48007 CLKBAR N47473 0 MbreakN
+ L=.18u
+ W=.72u
M_M34         OUTQ N48007 0 0 MbreakN
+ L=.18u
+ W=.72u
V_V20         N47477 0 1.8Vdc
C_C4         0 OUTQ  20p  TC=0,0
M_M23         N47337 CLK N47351 0 Mbreakn
+ L=.18u
+ W=.72u
M_M26         N47473 N47351 0 0 MbreakN
+ L=.18u
+ W=.72u
M_M41         CLKBAR CLK N48863 N48863 MbreakP
+ L=.18u
+ W=.72u
V_V25         N48241 0 1.8Vdc
V_V22         N47863 0 1.8Vdc
M_M39         N48007 CLK OUTQBAR 0 MbreakN
+ L=.18u
+ W=.72u
M_M42         CLKBAR CLK 0 0 MbreakN
+ L=.18u
+ W=.72u
M_M36         OUTQBAR OUTQ 0 0 Mbreakn
+ L=.18u
+ W=.72u
V_V26         N48601 0 1.8Vdc
V_V30         N47337 0
+PULSE 0 1.8V 0 1n 1n 3u 6u
V_V29         CLK 0
+PULSE 0 1.8V 0 1n 1n 2u 4u
M_M40         OUTQBAR CLKBAR N48007 N47875 MbreakP
+ L=.18u
+ W=.72u
V_V21         N47631 0 1.8Vdc
V_V28         N48863 0 1.8Vdc
M_M30         N47351 CLK N47627 N47863 MbreakP
+ L=.18u
+ W=.72u
M_M24         N47351 CLKBAR N47337 N47383 Mbreakp
+ L=.18u
+ W=.72u
M_M33         OUTQ N48007 N48087 N48087 MbreakP
+ L=.18u
+ W=1.8u
M_M29         N47627 CLKBAR N47351 0 MbreakN
+ L=.18u
+ W=.72u
   H     T     \     d     l               °      C U R R I C U L U M     V I T A E               L I P I   B A N E R J E E               N o r m a l          	   i r i s 4 0 2 +         8         @   î¦   @    Zã+áñÐ@   ¢«èÑ         ­     	        W P S   O f f i c e       
